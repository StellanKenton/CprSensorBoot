# Keil uVision project CprSensorBoot.uvprojx, settings and files
target CprSensorBoot (5060960::V5.06 update 7 (build 960)::.\ACC5)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: CprSensorBoot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\User;..\User\App;..\User\BackTrace;..\User\Bsp;..\User\Drv;..\User\Lib;..\User\Port;..\User\SEGGER;..\User\rep;..\User\rep\service\console;..\User\rep\service\rtos;..\User\rep\tools\ringbuffer;..\User\rep\driver\drvadc;..\User\rep\driver\drvuart;..\User\rep\driver\drvgpio;..\User\rep\driver\drviic;..\User\rep\driver\drvanlogiic;..\User\rep\driver\drvspi;..\User\rep\driver\drvusb;..\User\rep\module\mpu6050;..\User\rep\module\w25qxxx;..\User\rep\module\gd25qxxx;..\User\rep\module\pca9535;..\User\rep\module\tm1651;..\User\rep\comm\frameparser;..\User\rep\comm\flowparser
  memory RVCT4: ROM 0x8000000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c iwdg.c rtc.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group App
    ../User/App/: app_system.c
  group Drv
    ../User/Drv/: drv_wdg.c drv_delay.c
  group Bsp
    ../User/Bsp/: bspspi.c bspanlogiic.c bsp_uart.c
  group Lib
    ../User/Lib/: lib_comm.c MD5.c encryption.c
  group Log
    ../User/SEGGER/: bsp_rtt.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../User/rep/service/console/: log.c console.c
    ../User/Port/: log_port.c rtos_port.c
    ../User/rep/service/rtos/: rtos.c
    ../User/rep/tools/ringbuffer/: ringbuffer.c
  group Rep
    ../User/rep/driver/drvanlogiic/: drvanlogiic.c drvanlogiic_debug.c
    ../User/Port/: drvanlogiic_port.c drvspi_port.c gd25qxxx_port.c pca9535_port.c tm1651_port.c
    ../User/rep/driver/drvspi/: drvspi.c drvspi_debug.c
    ../User/rep/module/gd25qxxx/: gd25qxxx.c gd25qxxx_debug.c
    ../User/rep/module/pca9535/: pca9535.c pca9535_debug.c
    ../User/rep/module/tm1651/: tm1651.c tm1651_debug.c
  group Trace
    ../User/BackTrace/: cm_backtrace.c
    ../User/BackTrace/fault_handler/keil/: cmb_fault.S
software components: CMSIS:CORE 4.3.0
